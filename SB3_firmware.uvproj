# Keil uVision project SB3_firmware.uvproj, settings and files
target SB3 (ARM-ADS)
  device: STM32F100RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SB3_firmware
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\lib\cmsis\cm3\coresupport;.\lib\cmsis\cm3\devicesupport\st\stm32f10x;.\lib\stm32f10x_stdperiph_driver\inc;.\user\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ./: startup_stm32f10x_md_vl.s
    ./lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ./user/src/: ADC.c LEDs.c main.c UART.c TIM.c
  group User Headers
    ./user/inc/: ADC.h LEDs.h UART.h TIM.h
  group Standard Periph Lib
    ./lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dac.c
    ./user/src/: stm32f10x_it.c
  group Standard Periph Lib Headers
    ./lib/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_dma.h stm32f10x_gpio.h stm32f10x_rcc.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_dac.h
    ./user/inc/: stm32f10x_conf.h stm32f10x_it.h
